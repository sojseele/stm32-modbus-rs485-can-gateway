# Keil uVision project Temprot.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Temprot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Libries\CMSIS\Device\ST\STM32F1xx\Include;..\Libries\CMSIS\Include;..\Libries\STM32F1xx_HAL_Driver\Inc;..\User;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group CMSIS
    ../Libries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_dma.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim_ex.c
  group USER
    ../User/: main.c stm32f1xx_it.c
    ../User/can/: bsp_can.c
    ../User/dwt/: bsp_dwt.c
    ../User/led/: bsp_led.c
    ../User/usart/: bsp_usart.c
    ../User/adc/: bsp_adc.c
    ../User/key/: bsp_key.c
    ../User/modbus/: bsp_modbus.c
    ../User/tim/: bsp_tim.c
    ../User/pwm/: bsp_pwm.c
    ../User/rs485/: bsp_rs485.c
    ../User/protocol/: bsp_can_protocol.c
  group APP
    ../App/modbus/: app_modbus.c
  group DOC
    ../Doc/: Readme.txt
